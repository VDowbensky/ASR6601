# Keil uVision project ASR6601test.uvprojx, settings and files
target asr6601 (6210000::V6.21::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ASR6601test +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=4
  c include: .\inc;.\lib\inc;.\chip;.\periph;.\radio;.\cli
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: main.c bsp.c tremo_it.c retarget.c app_cli.c
    ./periph/: adc.c
  group startup
    ./chip/: startup_tremo.s system_tremo.c
  group lib
    ./lib/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_wdg.c tremo_uart.c
  group peripherals
    ./periph/: gpio.c uart.c lorac.c flash.c
  group radio
    ./radio/: radio_proc.c sx126xx.c
  group cli
    ./cli/: command_interpreter.c
