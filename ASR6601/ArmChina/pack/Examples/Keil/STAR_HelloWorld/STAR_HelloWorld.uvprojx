# Keil uVision project STAR_HelloWorld.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STAR_CU ArmChina
  pack: ArmChina.STAR.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: STAR_HelloWorld
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\STAR_CU\STAR_ac6.sct
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.4.0, CMSIS Driver:USART:STAR USART 1.0.0, Device:Startup 1.0.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
