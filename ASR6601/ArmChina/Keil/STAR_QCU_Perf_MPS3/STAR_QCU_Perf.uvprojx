# Keil uVision project STAR_QCU_Perf.uvprojx, settings and files
target STAR (6190000::V6.19::ARMCLANG)
  device: STAR_CU_MPS3 ArmChina
  pack: ArmChina.STAR.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: STAR_QCU
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _BOARD_MPS3
  c include: .\Source\driver;.\Source\app
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\STAR_CU_MPS3\STAR_ac6.sct
  group main
    ./Source/main/: main.c
  group app
    ./Source/app/: Mat_mult.c Mat_mult.h Timing.c Timing.h
  group driver
    ./Source/driver/: Flash_api.c Flash_api.h Flash_driver.c Flash_driver.h
software components: CMSIS:CORE 5.4.0, CMSIS Driver:QSPI(Driver):STAR QCU 1.0.0, CMSIS Driver:USART:STAR USART 1.1.0, Device:Startup 1.1.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
